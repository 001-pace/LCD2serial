<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8l051_lcd1602_uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
